# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\BSP;..\..\User\Port;..\..\Ethernet;..\..\Ethernet\W5500;..\..\Application\loopback;..\..\Internet\MQTT;..\..\Internet\MQTT\MQTTPacket\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/BSP/: bsp.c
  group Port
    ../../User/Port/: utility.c w5500_conf.c
  group Ethernet
    ../../Ethernet/: socket.c wizchip_conf.c
    ../../Ethernet/W5500/: w5500.c
  group loopback
    ../../Application/loopback/: loopback.c
  group MQTT_APP
    ../../Internet/MQTT/: mqtt_interface.c MQTTClient.c
  group MQTT_PKG
    ../../Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
software components: CMSIS:CORE 4.3.0
